# Keil uVision project AIR_RADIO.uvproj, settings and files
target AIR_RADIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: AIR_RADIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\Software Delay;..\..\..\Include
  group Source
    ../: main.c
    ./: gpiofunc.c gpiofunc.h radiodecode.c radiodecode.h
  group Startup
    ../../../Startup/: STARTUP.A51
  group rf
    ../rf/: cmt_spi3.c cmt2300a.c cmt2300a_hal.c hw_layer.c if.c radio.c
  group Common
    ../../../Common/: Common.c
